# Keil uVision project Project.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C6 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00002800) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER MCU_STM32F103C
  c include: .\Startup;.\User;.\Library;.\System;.\Hardware;.\Board;.\Demo;.\Peripheral
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2800
  group User
    ./User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h Device_Config.h
  group Board
    ./Board/: STM32F103C_Dev_Board_V1.c STM32F103C_Dev_Board_V1.h
  group Peripheral
    ./Peripheral/: ADC.c ADC.h EXTI_Trigger.c EXTI_Trigger.h IIC_Hardware.c IIC_Hardware.h IIC_Software.c IIC_Software.h SPI_Hardware.c SPI_Hardware.h SPI_Software.c SPI_Software.h TIM_EncoderInterface.c TIM_EncoderInterface.h TIM_InputCapture.c TIM_InputCapture.h TIM_PWM.c TIM_PWM.h TIM_Time.c TIM_Time.h DMA.c DMA.h GPIO.c GPIO.h UART.c UART.h
  group Hardware
    ./Hardware/: OLED_Font.h 74HC595.c 74HC595.h MatrixLED.c MatrixLED.h Encoder.c Encoder.h 74HC138.c 74HC138.h OLED.h Sensor_DHT11.c Sensor_DHT11.h Servo_SG90.c Servo_SG90.h OLED_Display.c OLED_Driver.c
  group Library
    ./Library/: misc.c misc.h stm32f10x_adc.c stm32f10x_adc.h stm32f10x_bkp.c stm32f10x_bkp.h stm32f10x_can.c stm32f10x_can.h stm32f10x_cec.c stm32f10x_cec.h stm32f10x_crc.c stm32f10x_crc.h stm32f10x_dac.c stm32f10x_dac.h stm32f10x_dbgmcu.c stm32f10x_dbgmcu.h stm32f10x_dma.c stm32f10x_dma.h stm32f10x_exti.c stm32f10x_exti.h stm32f10x_flash.c stm32f10x_flash.h stm32f10x_fsmc.c stm32f10x_fsmc.h stm32f10x_gpio.c stm32f10x_gpio.h stm32f10x_i2c.c stm32f10x_i2c.h stm32f10x_iwdg.c stm32f10x_iwdg.h stm32f10x_pwr.c stm32f10x_pwr.h stm32f10x_rcc.c stm32f10x_rcc.h stm32f10x_rtc.c stm32f10x_rtc.h stm32f10x_sdio.c stm32f10x_sdio.h stm32f10x_spi.c stm32f10x_spi.h stm32f10x_tim.c stm32f10x_tim.h stm32f10x_usart.c stm32f10x_usart.h stm32f10x_wwdg.c stm32f10x_wwdg.h
  group Startup
    ./Startup/: startup_stm32f10x_ld.s core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group System
    ./System/: STM32Device.h DataType.c DataType.h Delay.c Delay.h Pin_Config.h Pin_Config.c micro_math.c micro_math.h
